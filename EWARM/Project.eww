<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32f411_uart_logger.ewp</path>
  </project>
  <batchBuild />
</workspace>
